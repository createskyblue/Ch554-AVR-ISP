# Keil uVision project USBCompositeDevice.uvproj, settings and files
target Target 1 (MCS-51)
  device: SST89C54 SST
  cpu: IRAM(0-0xFF) IROM(0-0x3FFF) CLOCK(33000000)
  output: USBCompositeDevice +hex
  c flags: Optimize=8 SizeSpeed=1
  c define: CLOCK_FREQ_24
  c include: ..\CH55x_USB_CDC
  group Source Group 1
    ./: usb_ep0.c usb_desc.c usb_it.c usb_endp.c usb_string_desc.c i2c.c ch554_conf.c main.c bootloader.c delay.c usb_cdc.c spi.c stk500.c
